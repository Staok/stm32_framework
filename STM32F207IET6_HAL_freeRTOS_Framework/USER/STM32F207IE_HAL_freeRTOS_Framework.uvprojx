# Keil uVision project STM32F207IE_HAL_freeRTOS_Framework.uvprojx, settings and files
target STM32F207IE_Framework (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F207IE_HAL_freeRTOS_Framework +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: .\SYS\Inc;.\USER;..\CORE;..\CONFIG;..\HAL\Inc;..\Middlewares\MyString;..\Middlewares\pid;..\Middlewares\printf;..\Middlewares\simu_i2c_spi;..\Middlewares\malloc;..\DEVICES\TFTLCD;.\USER\menu;.\USER\BareConfig;.\USER\TaskConfig;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h
  group USER_SYS
    ./SYS/Src/: stm32f2xx_it.c system_stm32f2xx.c
    ./SYS/Inc/: startup_stm32f207xx.s
  group USER_USER
    ./USER/: main.c
    ./USER/BareConfig/: BareConfig.c
    ./USER/TaskConfig/: TaskConfig.c
    ./USER/menu/: sys_menu.c
  group CONFIG
    ../CONFIG/: PeriphConfig.c PeriphConfigCore.c
  group Middle
    ../Middlewares/MyString/: MyString.c
    ../Middlewares/pid/: pid.c
    ../Middlewares/printf/: printf.c
    ../Middlewares/simu_i2c_spi/: simui2c.c simuspi.c
    ../Middlewares/malloc/: malloc.c
    ../DEVICES/TFTLCD/: TFTLCD.c
  group HAL
    ../HAL/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dcmi_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_mmc.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_adc.c stm32f2xx_ll_crc.c stm32f2xx_ll_dac.c stm32f2xx_ll_dma.c stm32f2xx_ll_exti.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_gpio.c stm32f2xx_ll_i2c.c stm32f2xx_ll_pwr.c stm32f2xx_ll_rcc.c stm32f2xx_ll_rng.c stm32f2xx_ll_rtc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_spi.c stm32f2xx_ll_tim.c stm32f2xx_ll_usart.c stm32f2xx_ll_usb.c stm32f2xx_ll_utils.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
target STM32F207IE_Framework_TO_RAM (ARM-ADS)
  device: STM32F207IETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: STM32F207IE_HAL_freeRTOS_Framework +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
