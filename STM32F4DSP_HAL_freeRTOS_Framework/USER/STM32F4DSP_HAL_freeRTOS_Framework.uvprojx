# Keil uVision project STM32F4DSP_HAL_freeRTOS_Framework.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4DSP_HAL_freeRTOS_Framework
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM
  c include: .\SYS\Inc;.\USER;.\USER\BareConfig;.\USER\TaskConfig;.\USER\menu;..\CORE;..\CONFIG;..\HAL\Inc;..\DEVICES\TFTLCD;..\DEVICES\NetCard;..\DEVICES\SPI FLASH;..\ThirdPart\FreeRTOS\include;..\ThirdPart\FreeRTOS\portable\RVDS\ARM_CM4F;..\ThirdPart\LWIP\lwip-2.1.2\include;..\ThirdPart\LWIP\lwip_user;..\ThirdPart\DSP_LIB\Inc;..\ThirdPart\FATFS;..\Middles\malloc;..\Middles\lwrb;..\Middles\MyString;..\Middles\pid;..\Middles\printf;..\Middles\simu_i2c_spi;..\ThirdPart\LWIP\lwip_user\tcp_server;..\ThirdPart\LWIP\lwip_user\tcp_client;..\ThirdPart\LWIP\lwip_user\udp;..\ThirdPart\LWIP\lwip_user\web_server;..\DEVICES\FATFS plus;..\DEVICES\SPI SDcard;..\DEVICES\SPI FLASH SFUD\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h cmsis_armclang.h
  group USER_SYS
    ./SYS/Src/: stm32f4xx_it.c system_stm32f4xx.c
    ./SYS/Inc/: startup_stm32f407xx.s
  group USER_USER
    ./USER/: main.c
    ./USER/BareConfig/: BareConfig.c
    ./USER/TaskConfig/: TaskConfig.c
    ./USER/menu/: sys_menu.c
  group CONFIG
    ../CONFIG/: PeriphConfig.c PeriphConfigCore.c
  group Middle
    ../Middles/MyString/: MyString.c
    ../Middles/printf/: printf.c
    ../Middles/pid/: pid.c
    ../Middles/simu_i2c_spi/: simuspi.c simui2c.c
    ../Middles/malloc/: malloc.c
    ../Middles/lwrb/: lwrb.c
  group DEVICES
    ../DEVICES/TFTLCD/: TFTLCD.c
    ../DEVICES/NetCard/: NetCard.c
    ../DEVICES/FATFS plus/: fatfs_app.c
    ../DEVICES/SPI SDcard/: SPI_SDcard.c
    ../DEVICES/SPI FLASH SFUD/src/: sfud.c sfud_sfdp.c
    ../DEVICES/SPI FLASH SFUD/port/: sfud_port.c
  group FATFS
    ../ThirdPart/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS_CORE
    ../ThirdPart/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../ThirdPart/FreeRTOS/portable/MemMang/: heap_4.c
    ../ThirdPart/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group LWIP_USER
    ../ThirdPart/LWIP/lwip_user/: lwip_comm.c sys_arch.c
    ../ThirdPart/LWIP/lwip_user/udp/: udp.c
  group LWIP_CORE
    ../ThirdPart/LWIP/lwip-2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../ThirdPart/LWIP/lwip-2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../ThirdPart/LWIP/lwip-2.1.2/netif/: ethernet.c
  group LWIP_API
    ../ThirdPart/LWIP/lwip-2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group DSP_LIB
    ../ThirdPart/DSP_LIB/: arm_cortexM4lf_math.lib
  group HAL
    ../HAL/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Docs
    ../Docs/: docs.bin
target SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM32F4DSP_HAL_freeRTOS_Framework
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c include: .\SYS\Inc;.\USER;.\USER\BareConfig;.\USER\menu;.\USER\TaskConfig;..\CONFIG;..\CORE;..\DEVICES\FATFS plus;..\DEVICES\MAX7219;..\DEVICES\MPU6050;..\DEVICES\NetCard;..\DEVICES\OLED;..\DEVICES\SPI FLASH SFUD\inc;..\DEVICES\SPI SDcard;..\DEVICES\TFTLCD;..\HAL\Inc;..\Middles\lwrb;..\Middles\malloc;..\Middles\MyString;..\Middles\pid;..\Middles\printf;..\Middles\simu_i2c_spi;..\ThirdPart\DSP_LIB\Inc;..\ThirdPart\FATFS;..\ThirdPart\FreeRTOS\include;..\ThirdPart\LWIP\lwip_user;..\ThirdPart\LWIP\lwip-2.1.2\include;..\ThirdPart\LWIP\lwip_user\udp;..\ThirdPart\LWIP\lwip_user\tcp_client;..\ThirdPart\LWIP\lwip_user\tcp_server;..\ThirdPart\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
