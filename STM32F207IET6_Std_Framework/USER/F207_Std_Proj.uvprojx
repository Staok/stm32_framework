# Keil uVision project F207_Std_Proj.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F207_Std_Proj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F2XX,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\StdLib\inc;.\SYS;.\USER;..\Malloc;..\Fatfs\fatfs_app;..\Fatfs\src;..\Fatfs\src\option;..\APP\led;..\APP\spi;..\APP\sd;..\APP\can;..\APP\simu_i2c_spi;..\APP\SPI SDcard;..\APP\time
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CORE
    ../CORE/: arm_common_tables.h core_cm3.h core_cmFunc.h core_cmInstr.h
    ./SYS/: startup_stm32f2xx.s
  group APP
    ../APP/led/: led.c
    ../APP/spi/: spi.c
    ../APP/sd/: sdio_sdcard.c
    ../APP/can/: can.c
    ../APP/SPI SDcard/: SPI_SDcard.c
    ../APP/simu_i2c_spi/: simuspi.c
    ../APP/time/: time.c
  group StdLib
    ../StdLib/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group USER
    ./: main.c
    ./USER/: system.c SysTick.c usart.c
    ./SYS/: stm32f2xx_it.c system_stm32f2xx.c
  group MALLOC
    ../Malloc/: malloc.c
  group FATFS
    ../Fatfs/src/: diskio.c ff.c
    ../Fatfs/fatfs_app/: fatfs_app.c
    ../Fatfs/src/option/: cc936.c
